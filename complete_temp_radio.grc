<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_band_decimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bp_width</value></param>
<param><key>value</key><value>16000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>288000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuning_offset</value></param>
<param><key>value</key><value>-64000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-tuning_offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>tuning_offset + (bp_width/2)</value></param>
<param><key>low_cutoff_freq</key><value>tuning_offset - (bp_width/2)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>bp_width/5</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>C:\Users\parsve\rtl-433sensor\rfdumps\gqrx_20161228_205605_433960000_288000_fc_burst.aiff</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.6</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.4</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, threshold=0.5, sample_rate=10, max_symbol_time=10.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Run length measurement',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.threshold = threshold
        self.sample_rate = sample_rate
        self.max_symbol_time = max_symbol_time
        self.is_high = False
        self.streak_count = 0


    def general_work(self, input_items, output_items):
        """example: multiply with constant"""
        # output_items[0][:] = input_items[0] #* self.threshold

        input = input_items[0]
        out = output_items[0]

        i = 0
        while i &lt; len(input):
            self.consume(0,1)
            if(self.is_high):
                if(input[i] &lt; self.threshold):
                    self.is_high = False
                    out[0] = (self.streak_count + 1.0 )/ self.sample_rate
                    #print str(out[0]) + " ms HI"
                    #print str(self.streak_count) + " samples"
                    self.streak_count = 0
                    return 1
            else:
                if(input[i] &gt;= self.threshold):
                    self.is_high = True
                    out[0] = (self.streak_count + 1.0 )/ self.sample_rate
                    #print str(out[0]) + "ms LO"
                    #print str(self.streak_count) + " samples"
                    self.streak_count = 0
                    return 1
            i += 1
            self.streak_count += 1
        return 0
</value></param>
<param><key>max_symbol_time</key><value>10.0</value></param>
<param><key>sample_rate</key><value>samp_rate/base_band_decimation</value></param>
<param><key>threshold</key><value>0.5</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, level_threshold=0.5, time_threshold=0.001, sample_rate=10, guard_time=0.01):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='pwm decode bitstream',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.byte]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.level_threshold = level_threshold
        self.time_threshold = time_threshold
        self.sample_rate = sample_rate
        self.guard_time = guard_time
        self.latest_level = 0
        self.streak_count = 0


    def general_work(self, input_items, output_items):
        """example: multiply with constant"""
        # output_items[0][:] = input_items[0] #* self.threshold

        input = input_items[0]
        out = output_items[0]

        outcnt = 0

        i = 0
        self.consume(0,len(input))
        while i &lt; len(input):

            if input[i] &lt; self.level_threshold:
                current_item = 0
            else:
                current_item = 1

            switched = current_item != self.latest_level
            self.streak_count += 1

            if switched:
                if self.latest_level == 1:
                    if (self.streak_count + 1.0) / self.sample_rate &lt; self.time_threshold:
                        out[outcnt] = 0
                    else:
                        out[outcnt] = 1
                    outcnt += 1
                self.streak_count = 0
            else:
                if (self.streak_count + 1.0) / self.sample_rate &gt; self.guard_time:
                    out[outcnt] = -1
                    outcnt += 1
                    self.streak_count = 0
            self.latest_level = current_item
            i += 1
        return outcnt
</value></param>
<param><key>guard_time</key><value>0.01</value></param>
<param><key>level_threshold</key><value>0.5</value></param>
<param><key>sample_rate</key><value>samp_rate/base_band_decimation</value></param>
<param><key>time_threshold</key><value>0.001</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, example_param=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Print bytes',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = example_param

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        #        output_items[0][:] = input_items[0] * self.example_param
        print input_items[0][0]
        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>example_param</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, example_param=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Print bytes',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = example_param

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        #        output_items[0][:] = input_items[0] * self.example_param

        i = 0
        while i &lt; len(input_items[0]):
            print input_items[0][i]
            i += 1

        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>example_param</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr

IN_GUARD_LOW = 1
IN_GUARD_HIGH = 2
MEASURING_HIGH = 3
MEASURING_LOW = 4
PLAYING_CLOCK_LOW = 5
PLAYING_CLOCK_HIGH = 6

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, positive_edges_in_preamble=5 , sample_time=0.5, low_guard_no_of_samples = 1000):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Clock recovery',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        # self.example_param = example_param
        self.state = IN_GUARD_LOW
        self.previous_item = 0
        self.low_guard_no_of_samples = low_guard_no_of_samples
        self.positive_edges_in_preamble = positive_edges_in_preamble
        self.start_time = 0
        self.samples_per_cycle = 42

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        input = input_items[0]
        out = output_items[0]
        #self.consume(0, len(input))
        
        i = 0
        while i &lt; len(input):
            self.start_time += 1
            
            if input[i] &lt; 0.5:
                current_item = 0
            else:
                current_item = 1
                    
            switched = current_item != self.previous_item
            clockpulse = 0
            
            if self.state == IN_GUARD_LOW:
                if switched:
                    self.state = MEASURING_HIGH
                    self.start_time = 0
                    self.edges_detected_sofar = 1
            ##            elif self.state == IN_GUARD_HIGH:
            elif self.state == MEASURING_HIGH:
                if switched:
                    self.updateState(MEASURING_LOW)
            elif self.state == MEASURING_LOW:
                if switched:
                    self.edges_detected_sofar += 1
                    if self.edges_detected_sofar == self.positive_edges_in_preamble:
                        self.updateState(PLAYING_CLOCK_HIGH)
                        self.samples_per_cycle = int(self.start_time / (self.positive_edges_in_preamble - 1))
                        print "samples per cycle=" + str(self.samples_per_cycle)
                    else:
                        self.updateState(MEASURING_HIGH)
            
            elif self.state == PLAYING_CLOCK_LOW:
                if self.start_time % self.samples_per_cycle == 0:
                    clockpulse = 1
                if switched:
                    self.updateState(PLAYING_CLOCK_HIGH)
            elif self.state == PLAYING_CLOCK_HIGH:
                if self.start_time % self.samples_per_cycle == 0:
                    clockpulse = 1
                if switched:
                    self.updateState(PLAYING_CLOCK_LOW)


            self.previous_item = current_item
            out[i] = clockpulse * 0.8 + 0.1
            #out[i] = current_item * 0.8
                #      if(clockpulse == 1):
                #print "cp, time=" + str(self.start_time)
            i += 1
        return len(out)

    def updateState(self, state):
        oldstate = self.state
        self.state = state
        print str(oldstate) + " -&gt; " + str(state)
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>low_guard_no_of_samples</key><value>1000</value></param>
<param><key>positive_edges_in_preamble</key><value>8</value></param>
<param><key>sample_time</key><value>0.5</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import pmt
from gnuradio import gr

def bitsToByte(bits):
    return 128*bits[0] + 64*bits[1] + 32*bits[2] + 16*bits[3] + 8*bits[4] + 4*bits[5] + 2*bits[6] + 1*bits[7]




class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='bitstream to pdu',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[]
        )
        self.accumulated = []
        self.message_port_register_out(pmt.intern("binary_pdu_out"))


    def sendMessage(self, accumulated):
        bytes = []
        bytes.append(bitsToByte(accumulated[0:8]))
        bytes.append(bitsToByte(accumulated[8:16]))
        bytes.append(bitsToByte(accumulated[16:24]))
        bytes.append(bitsToByte(accumulated[24:32]))
        bytes.append(bitsToByte(accumulated[32:40]))
        bytes.append(bitsToByte(accumulated[40:48]))
        send_pmt = pmt.make_u8vector(len(bytes), 0)

        #print bytes

        for i in range(len(bytes)):
            pmt.u8vector_set(send_pmt, i, bytes[i])
        self.message_port_pub(pmt.intern('binary_pdu_out'), pmt.cons(pmt.PMT_NIL, send_pmt))
        #print "PAR" + str(send_pmt) + "PAR2"

    def general_work(self, input_items, output_items):
        input = input_items[0]
        i = 0
        self.consume(0,len(input))
        while i &lt; len(input):
            current = input[i]
            if current == -1:
                if len(self.accumulated) == 6 * 8 +1:
                    self.sendMessage(self.accumulated[1:49])
                    #print self.accumulated
                #else:
                    #print "len=" + str(len(self.accumulated))
                self.accumulated = []
            else:
                self.accumulated.append(current)
                # print "len=" + str(len(self.accumulated))

            i += 1
        return 0
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_4</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt
import string
import time
import datetime




class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Detect stuck bits in PDUs',   # will show up in GRC
            in_sig=[],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.message_port_register_in(pmt.intern("pdu_in"))
        self.set_msg_handler(pmt.intern("pdu_in"), self.pdu_in)
        self.anded = [0xff,0xff,0xff,0xff,0xff,0xff]
        self.ored = [0x00,0x00,0x00,0x00,0x00,0x00]
    def work(self, input_items, output_items):
        """example: multiply with constant"""
        output_items[0][:] = input_items[0] * self.example_param
        return len(output_items[0])

    def pdu_in(self, msg_pmt):
        """ Receiver a u8vector on the input port, and print it out. """
        # Collect metadata, convert to Python format:
        meta = pmt.to_python(pmt.car(msg_pmt))
        # Collect message, convert to Python format:
        msg = pmt.cdr(msg_pmt)
        # Make sure it's a u8vector
        if not pmt.is_u8vector(msg):
            print "[ERROR] Received invalid message type.\n"
            return
        # Convert to string:
        msg_str = "".join([chr(x) for x in pmt.u8vector_elements(msg)])
        # Just for good measure, and to avoid attacks, let's filter again:
        msg_str = filter(lambda x: x in string.printable, msg_str)
        # Print string, and if available, the metadata:

        elements = pmt.u8vector_elements(msg)
        self.anded[0] &amp;= elements[0]
        self.anded[1] &amp;= elements[1]
        self.anded[2] &amp;= elements[2]
        self.anded[3] &amp;= elements[3]
        self.anded[4] &amp;= elements[4]
        self.anded[5] &amp;= elements[5]

        self.ored[0] |= elements[0]
        self.ored[1] |= elements[1]
        self.ored[2] |= elements[2]
        self.ored[3] |= elements[3]
        self.ored[4] |= elements[4]
        self.ored[5] |= elements[5]

        hex_elements = " ".join([format(x, '02x') for x in elements])
        hex_anded = " ".join([format(x, '02x') for x in self.anded])
        hex_ored = " ".join([format(x, '02x') for x in self.ored])

        ts = time.time()
        st = datetime.datetime.fromtimestamp(ts).strftime('%Y-%m-%d %H:%M:%S')
        print "At time: " + st
        print " Pdu received:   " +  hex_elements
        print " Accumulated AND " + hex_anded
        print " Accumulated  OR " + hex_ored
        if meta is not None:
            print "[METADATA]: ", meta
</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bp_width*4</value></param>
<param><key>decim</key><value>base_band_decimation</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1.5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>bp_width</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>label1</key><value>Width of LOW signal (Seconds)</value></param>
<param><key>xmax</key><value>0.005</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>label1</key><value>Width of HIGH signal (Seconds)</value></param>
<param><key>xmax</key><value>0.005</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>xmax</key><value>0.005</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>bins</key><value>200</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate/base_band_decimation</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/base_band_decimation</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>433960000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_0</source_block_id><sink_block_id>epy_block_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_0</source_block_id><sink_block_id>epy_block_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_3</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>binary_pdu_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>epy_block_3</source_block_id><sink_block_id>epy_block_4</sink_block_id><source_key>binary_pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
